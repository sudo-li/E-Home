# Keil uVision project time12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: time12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\APP\LCD12864;.\APP\ds1302;.\APP\24c02;.\APP\ds18b20;.\APP\DHT11;.\APP\key
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./APP/: main.c
    ./APP/LCD12864/: lcd.c
    ./APP/ds1302/: ds1302.c
    ./APP/24c02/: 24c02.c
    ./APP/ds18b20/: ds18b20.c
    ./APP/key/: key.c
